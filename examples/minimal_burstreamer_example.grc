options:
  parameters:
    author: Francisco Albani
    generate_options: qt_gui
    id: minimal_burstreamer_example
    output_language: python
    title: minimal_burstreamer_example
  states: {}

blocks:
- name: consumer_samp_rate
  id: variable
  parameters:
    value: producer_samp_rate  *10
  states: {}
- name: producer_samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1000'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: consumer_samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: producer_samp_rate
    type: complex
  states: {}
- name: burstream_burstreamer_c_0
  id: burstream_burstreamer_c
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    size: '12314'
    srate: consumer_samp_rate
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, burstream_burstreamer_c_0, pdus]
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [burstream_burstreamer_c_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
